# Keil uVision project Team_27_Feedback_Heater.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Team_27_Feedback_Heater
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c tm4c123gh6pm.h Dio.c Dio.h Dio_config.c Dio_config.h adc.c adc.h lcd.c lcd.h Macro.h types.h
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.5.0, Device:Startup 1.0.1
